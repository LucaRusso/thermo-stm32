# Keil uVision project Progetto_STM32F401RE.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Progetto_STM32F401RE +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: startup_stm32f401xe.s Prototipi.h Main.c Gestisci_Clock.c Real_Time_Clock.c Utility.c Floating_Point_Unit.c LCD.c Termistore.c Pulsante.c Interfaccia.c LED.c Seriale.c Active Buzzer.c
